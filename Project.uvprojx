# Keil uVision project Project.uvprojx, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: SizeSpeed=1
  c define: DEBUG
  c include: .\ADC;.\Deja_vu;.\Global;.\interrupt;.\Main;.\Motor;.\PWM;.\Timer;.\USART;..\DC_motors;.\Task;.\Buzzer;.\LED
  group ADC
    ./ADC/: ADC.c ADC.h
  group Deja_vu
    ./Deja_vu/: Deja_vu.c Deja_vu.h
  group Global
    ./Global/: Global.c Global.h
  group interrupt
    ./interrupt/: interrupt.c interrupt.h
  group Main
    ./Main/: main.c
  group Motor
    ./Motor/: Motor.c motor.h Motors_Break.c Motors_Break.h
  group PWM
    ./PWM/: PWM.c pwm.h
  group Timer
    ./Timer/: timer.c timer.h
  group USART
    ./USART/: USART.c USART.h
  group Buzzer
    ./Buzzer/: Buzzer.c Buzzer.h
  group Task
    ./Task/: Task.c Task.h
  group LED
    ./LED/: LED.c LED.h
